# Keil uVision project follower.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: follower +hex
  AfterMake: fromelf.exe --bin -o follower.bin ./output/follower.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_I2C,USE_DISPLAY,USE_PI
  c include: ../../sdk/bundles/extension/inc;../../sdk/bundles/extension/inc/os;../../sdk/src/BSP;../../sdk/src/FWlib;../../sdk/src/StartUP/ing918;../../sdk/src/Tools;../../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x28000 size 0x5c000
  memory RVCT9: RAM 0x20007918 size 0x86e8
  group APP
    ./src/: main.c profile.c service_console.c kalman.c ota_service.c vehicle.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../sdk/bundles/extension/ING9188xx/: symdefs.m
  group BSP
    ../../sdk/src/BSP/: iic.c eflash.c
  group FWlib
    ../../sdk/src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c peripheral_i2c.c peripheral_gpio.c peripheral_pwm.c
  group Tools
    ../../sdk/src/Tools/: trace.c ad_parser.c gatt_client_util.c str_util.c rf_util.c
software components: CMSIS:CORE 4.3.0
